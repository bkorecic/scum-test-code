# Keil uVision project helper_data_gen.uvprojx, settings and files
target helper_data_gen (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: helper_data_gen +hex
  AfterMake: fromelf --bin .\Objects\helper_data_gen.axf -o .\Objects\helper_data_gen.bin
  AfterMake: fromelf -cvf .\Objects\helper_data_gen.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../../../../;../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: helper_data_gen.c
  group drv
    ../../../../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c
  group repetition_code
    ../: bit_utils.c bit_utils.h repetition_code.c repetition_code.h
