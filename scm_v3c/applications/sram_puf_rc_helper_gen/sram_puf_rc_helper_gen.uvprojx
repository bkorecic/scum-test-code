# Keil uVision project sram_puf_rc_helper_gen.uvprojx, settings and files
target sram_puf_rc_helper_gen.uvprojx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: sram_puf_rc_helper_gen.uvprojx +hex
  AfterMake: fromelf --bin .\Objects\sram_puf_rc_helper_gen.uvprojx.axf -o .\Objects\puf_helper.bin
  AfterMake: fromelf -cvf .\Objects\sram_puf_rc_helper_gen.uvprojx.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: sram_puf_rc_helper_gen.uvprojx.c
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c
